	list p=16f877a
	include "p16f877a.inc"

	org 00h	

inicio	
		BSF		STATUS,5	;Cambio de banco
		MOVLW   B'00000100'
		MOVWF   CMCON
		MOVLW  	D'25'
		MOVWF   SPBRG	
		MOVLW   D'36'
		MOVWF   TXSTA
	
		BCF		STATUS,5

		MOVLW   D'128'
		MOVWF   RCSTA

INICIO  BSF		STATUS,5
		BTFSC   CMCON,6
		GOTO  	SIGUE
		BTFSC	CMCON,7
		GOTO	INICIO
		MOVLW   B'01100000'
		BCF		STATUS,5
		MOVWF   TXREG
		GOTO 	INICIO
		
SIGUE	BTFSC	CMCON,7
		GOTO	MAYOR
		MOVLW   B'11011010'
		BCF		STATUS,5
		MOVWF   TXREG
		GOTO 	INICIO
MAYOR	MOVLW   B'11110010'
		BCF		STATUS,5
		MOVWF   TXREG
		GOTO    INICIO
		END	